* Testcase 8

V_Vesq   nome_extremamente_longo_para_o_no_b       0     -5.4662375
*H_Hesq     nome_extremamente_longo_para_o_no_b     0     V_amp     6250m
R_Resq     nome_extremamente_longo_para_o_no_a     0     20
I_Icima     nome_extremamente_longo_para_o_no_a     nome_extremamente_longo_para_o_no_b     5
R_Rmeio     nome_extremamente_longo_para_o_no_a     c     10
R_Rdi_1     c     nome_extremamente_longo_para_o_no_b     40
R_Rdi_2     c     nome_extremamente_longo_para_o_no_b     60
V_Vdir     c     nome_longo_para_o_no_d_com_simbolos%_!_+     10
R_Rdi_3     nome_longo_para_o_no_d_com_simbolos%_!_+     0     20
R_Rdi_4 c     f     20
V_Vamp     f     0     0
