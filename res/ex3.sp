* Testcase 2-3 (1-7)

H_Hesq	b	0	R_Rdi_4	6250m
R_Resq	a	0	20
I_Icima	a	b	5
R_Rmeio	a	c	10
R_Rdi_1	c	b	40
R_Rdi_2	c	b	60
V_Vdir	c	d	10
R_Rdi_3	d	0	20
R_Rdi_4 c	0	20

.op
