* Testcase 2
Ve1 1 0 40000m
Re2 1 2 0.01k
Ie3 3 2 0.000005Meg
Re4 3 0 10000000u
Re5 2 4 5
Re6 4 0 10
Ge7 0 4 2 4 2
