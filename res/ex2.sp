* Testcase 2
Ve1 node1 0 40
Re2 node1 node2 10
Ie3 node3 node2 5
Re4 node3 0 10
Re5 node2 node4 5
Re6 node4 0 10
Ge7 0 node4 node2 node4 2
