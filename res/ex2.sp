* Testcase 2-2 (1-5)

* Elemento   n+       n-       nx+      nx-   valor
R_Rleft      node_A        0                      5
R_Rtopleft   node_A   node_B                     10
R_Rmiddle    node_B   node_C                      3
I_Itop       node_B   node_D                      3
I_Iright     node_D   node_C                      2
V_Vbottom    node_C        0                     18
V_Vright     node_D   node_E                      9
E_Eright     node_E   node_F   node_A   node_B    3
R_Rright     node_F        0                      9

.op
