* Testcase 2-5

Vesq  A   0  100
Resq1 A   vx  10
Resq2 vx  0   20
Resq3 vx  B    10
Gesq  B   0   vy  0  10m

Rdir1 C   0   10
Edir  vy  C   vx  0 30
Rdir2 vy  0   10
Rdir3 vy  0   10

.op
