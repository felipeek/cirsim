* Testcase 7

V_Vesq	b       0	-5.4662375
*H_Hesq	b	0	V_amp	6250m
R_Resq	a	0	20
I_Icima	a	b	5
R_Rmeio	a	c	10
R_Rdi_1	c	b	40
R_Rdi_2	c	b	60
V_Vdir	c	d	10
R_Rdi_3	d	0	20
R_Rdi_4 c	f	20
V_amp	f	0	0
