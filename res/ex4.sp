* Testcase 2-4

Rww no1   0  5
Rnw no1 no2 10
Rnn no2 no3  3
Inn no2 no4  3
Vss no3   0 18
Ins no4 no3  2
Vne no4 no5  9
Ene no5 no6 no1 no2 3
Rse no6 0    9

.op
