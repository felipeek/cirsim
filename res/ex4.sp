* Testcase 4
Ve1 1 0 4E1
Re2 1 2 1E1
Ie3 3 2 50E-1
Re4 3 0 1E1
Re5 2 4 500E-2
Re6 4 0 0.1E2
Ge7 0 4 2 4 20E-1
