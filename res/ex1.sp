* Testcase 1
Ve1 1 0 40
Re2 1 2 10
Ie3 3 2 5
Re4 3 0 10
Re5 2 4 5
Re6 4 0 10
Fe7 0 4 banana 2

.OP
