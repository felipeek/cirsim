* Testcase 9

M_M1 N_ZN_M0_d N_A_M0_g N_VDD_M0_s PMOS_VTL
*VDD PMOS_VTL
*W=0.135000U L=0.050000U AS=0.014175P AD=0.014175P PS=0.480000U PD=0.480000U
M_M0 N_ZN_M1_d N_A_M1_g N_VSS_M1_s NMOS_VTL
*VSS NMOS_VTL
*W=0.090000U L=0.050000U AS=0.009450P AD=0.009450P PS=0.390000U PD=0.390000U
C_x_PM_INV_X1%VSS_c0 VSS VSS 4.04285e-17
C_x_PM_INV_X1%VSS_c1 VSS x_PM_INV_X1%VSS_6 1.05124e-17
C_x_PM_INV_X1%VSS_c2 VSS N_VSS_M1_s 2.31636e-17
R_x_PM_INV_X1%VSS_r3 VSS x_PM_INV_X1%VSS_6 0.178824
R_x_PM_INV_X1%VSS_r4 x_PM_INV_X1%VSS_6 x_PM_INV_X1%VSS_2 0.264221
R_x_PM_INV_X1%VSS_r5 N_VSS_M1_s x_PM_INV_X1%VSS_2 0.637857
C_x_PM_INV_X1%VDD_c0 VSS VDD 4.07945e-17
C_x_PM_INV_X1%VDD_c1 VSS x_PM_INV_X1%VDD_6 1.04356e-17
C_x_PM_INV_X1%VDD_c2 VSS N_VDD_M0_s 1.64358e-17
R_x_PM_INV_X1%VDD_r3 VDD x_PM_INV_X1%VDD_6 0.178824
R_x_PM_INV_X1%VDD_r4 x_PM_INV_X1%VDD_6 x_PM_INV_X1%VDD_2 0.264221
R_x_PM_INV_X1%VDD_r5 N_VDD_M0_s x_PM_INV_X1%VDD_2 0.393571
C_x_PM_INV_X1%A_c0 VSS x_PM_INV_X1%A_14 8.49607e-18
C_x_PM_INV_X1%A_c1 VSS x_PM_INV_X1%A_12 3.68113e-17
C_x_PM_INV_X1%A_c2 VSS N_A_M0_g 8.65221e-17
C_x_PM_INV_X1%A_c3 VSS N_A_M1_g 4.18099e-17
R_x_PM_INV_X1%A_r4 x_PM_INV_X1%A_18 x_PM_INV_X1%A_14 4.74714
R_x_PM_INV_X1%A_r5 x_PM_INV_X1%A_17 x_PM_INV_X1%A_14 4.74714
R_x_PM_INV_X1%A_r6 x_PM_INV_X1%A_14 x_PM_INV_X1%A_12 25.0012
R_x_PM_INV_X1%A_r7 x_PM_INV_X1%A_12 A 0.156071
R_x_PM_INV_X1%A_r8 N_A_M0_g x_PM_INV_X1%A_18 106.47
R_x_PM_INV_X1%A_r9 N_A_M1_g x_PM_INV_X1%A_17 38.22
C_x_PM_INV_X1%ZN_c0 VSS N_ZN_M0_d 3.98114e-17
C_x_PM_INV_X1%ZN_c1 VSS N_ZN_M1_d 4.09557e-17
C_x_PM_INV_X1%ZN_c2 VSS ZN 8.74217e-17
R_x_PM_INV_X1%ZN_r3 x_PM_INV_X1%ZN_4 N_ZN_M0_d 0.30478
R_x_PM_INV_X1%ZN_r4 ZN x_PM_INV_X1%ZN_4 2.63286
R_x_PM_INV_X1%ZN_r5 x_PM_INV_X1%ZN_3 N_ZN_M1_d 0.30478
R_x_PM_INV_X1%ZN_r6 ZN x_PM_INV_X1%ZN_3 1.87286
